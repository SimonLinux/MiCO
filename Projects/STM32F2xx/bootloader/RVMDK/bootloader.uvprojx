# Keil uVision project bootloader.uvprojx, settings and files
target MiCOKit-3162 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: D:\Applications\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\Bootloader\MiCOKit-3162\Obj_RVMDK\bootloader.axf --output ..\..\..\..\Build\Bootloader\Output\MiCOKit-3162\Bootloader.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER BOOTLOADER SIZE_OPTIMIZE NO_MICO_RTOS
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Bootloader;..\..\..\..\include;..\..\..\..\Board\MiCOKit-3162;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\STM32F2xx\peripherals;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries;..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\libraries\utilities;..\..\..\..\MICO\system;..\..\..\..\MICO\system\command_console;..\..\..\..\MICO\system\config_server;..\..\..\..\MICO\system\easylink;..\..\..\..\MICO\system\mdns;..\..\..\..\MICO\system\tftp_ota
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Board\MiCOKit-3162\bootloaderLinkerForKeil.sct
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoSRPServer.h Common.h Debug.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group Board/MiCO-3162
    ../../../../Board/MiCOKit-3162/: platform.c platform.h platform_config.h
  group Board/MiCO-F205
    ../../../../Board/MiCOKit-F205/: platform.c platform.h platform_config.h
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c
  group Platform/Drivers/SPI_Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F2xx
    ../../../../Platform/MCU/STM32F2xx/: platform_init.c
  group Platform/MCU/STM32F2xx/RVMDK
    ../../../../Platform/MCU/STM32F2xx/RVMDK/: startup_stm32f2xx_bootloader_RVMDK.s
  group Platform/MCU/STM32F2xx/perrpherals
    ../../../../Platform/MCU/STM32F2xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c platform_nano_second.c
  group Platform/MCU/STM32F2xx/perrpherals/Libraries
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/: system_stm32f2xx.c
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Libraries/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c CheckSumUtils.h RingBufferUtils.c RingBufferUtils.h StringUtils.c StringUtils.h
  group MICO/system
    ../../../../MICO/system/: system.h
target MiCOKit-F205 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: as above
  output: bootloader
  AfterMake: D:\Applications\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\Bootloader\MiCOKit-F205\Obj_RVMDK\bootloader.axf --output ..\..\..\..\Build\Bootloader\Output\MiCOKit-F205\Bootloader.bin
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER BOOTLOADER NO_MICO_RTOS
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Bootloader;..\..\..\..\include;..\..\..\..\MICO\system;..\..\..\..\Board\MiCOKit-F205;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\STM32F2xx\peripherals;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries;..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\libraries\utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Board\MiCOKit-F205\bootloaderLinkerForKeil.sct
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
