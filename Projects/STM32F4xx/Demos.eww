<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader\EWARM\Bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.MicoKit\EWARM\COM.MXCHIP.MicoKit.ewp</path>
  </project>
  <batchBuild/>
</workspace>


